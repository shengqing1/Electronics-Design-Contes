# Keil uVision project empty_LP_MSPM0L1306_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0L1306_nortos_keil (6190000::V6.19::ARMCLANG)
  device: MSPM0L1306 Texas Instruments
  pack: TexasInstruments.MSPM0L11XX_L13XX_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0L1306_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L1306__
  c include: ..\..\source\third_party\CMSIS\Core\Include;..\..\source;..\ti;..\..\empty
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\mspm0l1306.sct
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0l130x_uvision.s
  group Driverlib
    ../ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
  group Hardware
    ../ti/: bsp_tb6612.c srevo.c motor.c filter.c guang.c
    ../: PID.c Encoder.c serial.c
